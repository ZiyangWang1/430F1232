<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\iar_8_0_4_0.ewp</path>
    </project>
    <batchBuild />
</workspace>
